# Keil uVision project pro.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\SYSTEM;..\DEVICE_LIB\inc;..\HARDWARE\keyboard;..\HARDWARE\printf;..\HARDWARE\usart1;..\HARDWARE\delay;..\HARDWARE\steeringengine;..\HARDWARE\bluetooth;..\HARDWARE\through-beam;..\HARDWARE\Temp;..\HARDWARE\24C02;..\HARDWARE\LCD;..\HARDWARE\TOUCH;..\HARDWARE\Raindrop_detection;..\HARDWARE\heater_plate;..\HARDWARE\Common;..\HARDWARE\JQ8900-16P
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_fsmc.c
  group HARDWARE
    ../HARDWARE/keyboard/: keyboard.c
    ../HARDWARE/printf/: printf.c
    ../HARDWARE/usart1/: usart1.c
    ../HARDWARE/delay/: delay.c
    ../HARDWARE/steeringengine/: steering.c
    ../HARDWARE/bluetooth/: bluetooth.c
    ../HARDWARE/through-beam/: through-beam.c
    ../HARDWARE/Temp/: DS18B20.c
    ../HARDWARE/mqtt/: cJSON.c
    ../HARDWARE/24C02/: 24c02.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/Raindrop_detection/: Raindrop_detection.c
    ../HARDWARE/heater_plate/: heater_plate.c
    ../HARDWARE/Common/: common.c
    ../HARDWARE/JQ8900-16P/: jq8900.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h sys.c
  group USER
    ./: main.c stm32f4xx_it.c
